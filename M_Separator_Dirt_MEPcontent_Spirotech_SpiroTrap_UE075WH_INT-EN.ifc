Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_UE075WH_INT-EN.ifc
Time: 2025-08-05T18:36:02+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_2196795_1 | SINK
OutPort_2196795_2 | SOURCE

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_UE022WH-UE100WH_INT-EN:UE075WH, M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_UE022WH-UE100WH_INT-EN:UE075WH:2196795
In: F00
Type - Material: Color RGB 055-055-055, Color RGB 168-128-048, Color RGB 235-235-235
Type - Other - Category: Pipe Accessories; Array Radius 1: 31.2 mm; Array Radius 2: 16.14 mm; Array Radius 3: 26.52 mm; Array Side Gap: 0.8 mm; b: 119 mm; B1: 137 mm; Center Distance: 0 mm; Connection Nominal Diameter: 19 mm; Connection Outer Diameter: 26.9 mm; Connector Depth 1: 13 mm; Connector Depth 2: 13 mm; d: 26.9 mm; D1: 81 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_UE022WH-UE100WH_INT-EN; h: 83 mm; h1: 32 mm; Hexagonal Diameter: 36 mm; Hexagonal Radius: 12 mm; Hh: 115 mm; Hv: 129 mm; L: 92 mm; Number of Rings: 30; Outer Diameter: 29.59 mm; Radius 1: 5 mm; Radius 2: 31.897 mm; Radius 3: 37.296 mm; Radius 4: 33.876 mm; Radius 5: 37.78 mm; Total Width: 81.114 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19 mm; Depth: 137 mm; Height: 164 mm; Use Nominal Diameter: yes; Width: 81 mm
Type - Identity Data - Article Description: Dirt separator - Brass - Uni 3/4" - Magnet; Article Type: UE075WH; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Dirt separator - Brass - Uni 3/4" - Magnet; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 24.07; GLN: 8717811000007; GTIN: 8717811046425; Manufacturer: Spirotech; Manufacturer Art. No.: UE075WH; Manufacturer URL: https://www.spirotech.com/8717811046425; MEPcontent Class: SEPARATOR_DIRT; Model: UE075WH; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: Spirotech; Revit Version: 2023; Type Name: UE075WH; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Brass Yellow: Color RGB 168-128-048; White: Color RGB 235-235-235
Type - Mechanical - Design Standard: EN 13445; Max Flow: 0.000361111 m3/s; Maximum Operating Pressure: 1000000 Pa; Maximum Temperature: 110 C; Maximum Velocity: 1 m/s; Volume: 0.00036 m3; Weight: 2.2 kg
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: UE075WH; sets with these values: 2
Other - Bottom Clearance Safe: 110 mm; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_UE022WH-UE100WH_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_UE022WH-UE100WH_INT-EN: UE075WH; Top Clearance Safe: 50 mm; Type: UE075WH; Type Id: 2196115
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.071094 m2; Maximum Size: 19 mm; Minimum Size: 19 mm; Volume: 0.000516661 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow Out: 0 m3/s; Pressure Drop: 0 Pa
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 100 mm; Service Space: no; Top Clearance: 50 mm
Insulation - Insulation Thickness: 0 mm
